## boards/shields/aht/Kconfig.defconfig
```kconfig
if SHIELD_AHT

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "aht"

endif
```
